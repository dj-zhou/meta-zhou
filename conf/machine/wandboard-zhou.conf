## conf/machine/wandboard-zhou.conf
```bitbake
require conf/machine/wandboard.conf
UBOOT_MACHINE = "wandboard_config"
KERNEL_DEVICETREE = "imx6qp-wandboard-revd1.dtb"
```
